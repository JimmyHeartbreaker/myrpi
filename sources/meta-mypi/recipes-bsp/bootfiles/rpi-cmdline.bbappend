CMDLINE:remove = "console=serial0,115200"
CMDLINE += " console=ttyAMA0,115200"
CMDLINE += " console=tty1"
