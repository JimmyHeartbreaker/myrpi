#FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"